# Copyright (c) 2014 LG Electronics, Inc.

# Overriding recipe in meta-webos-backports to correct license
LICENSE = "LGPLv2.1 & MIT & GPLv2"

EXTENDPRAUTO_append = "webos1"
