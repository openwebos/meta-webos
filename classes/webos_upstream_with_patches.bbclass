# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 
#
# webos_upstream_with_patches
#
# This class is to be inherited by the recipe for every upstream component to
# which we've added our own patches that is able to support having the filesystem 
# layout rooted at /opt/webos.
#

inherit webos_fs_layout
