# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 
#
# webos_kernel_dep
#
# The recipe for every component that needs the non-generic kernel headers must
# inherit this file.
#

# XXX Append -I${STAGING_KERNEL_DIR}/include to CFLAGS

