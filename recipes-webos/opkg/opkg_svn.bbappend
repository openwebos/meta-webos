# Copyright (c) 2013 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

EXTRA_OECONF_class-target += "--with-opkglockfile=${localstatedir}/lock/opkg"
