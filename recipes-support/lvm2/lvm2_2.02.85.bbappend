# (c) Copyright 2012  Hewlett-Packard Development Company, L.P.

PR_append = "webos1"

EXTRA_OECONF += "--disable-selinux \
                 --with-cluster=none \
                "
