# Copyright (c) 2012-2013 LG Electronics, Inc.
#
# webos_arch_indep
#
# This class is to be inherited by the recipe for every component that is CPU 
# architecture independent.
#

inherit allarch
