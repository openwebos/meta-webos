# Copyright (c) 2013 Hewlett-Packard Development Company, L.P.

PR_append = "webos1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
