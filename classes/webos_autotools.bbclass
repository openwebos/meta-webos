# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 
#
# webos_autotools
#
# This class is to be inherited by the recipe for every component that uses
# autotools for configuration.
#

inherit autotools

