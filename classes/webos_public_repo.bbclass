# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 
#
# webos_public_repo
#
# This class is to be inherited by the recipe for every component that has (or
# will have) a public Open weboS repo.
#

