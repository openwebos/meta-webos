# Copyright (c) 2012-2013 LG Electronics, Inc.
#
# webos_machine_impl_dep
#
# This class is to be inherited by the recipe for every component that depends
# on the "machine implementation" at build time.
#
