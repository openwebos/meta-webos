# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 

require cmake.inc
inherit native

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e1b237aeaed880f65dec9c20602452f6"
SRC_URI[sha256sum] = "130923053d8fe1a2ae032a3f09021f9024bf29d7a04ed10ae04647ff00ecf59f"

