# Copyright (c) 2012-2013 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

EXTRA_OECONF += "--disable-selinux \
                 --with-cluster=none \
                "
