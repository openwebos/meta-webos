# (c) Copyright 2012  Hewlett-Packard Development Company, L.P. 
#
# webos_pkgconfig
#
# This class is to be inherited by the recipe for every component that stages a
# pkgconfig (.pc) file. This usually happens implicitly by inheriting webos_library.
#

inherit pkgconfig
