# Copyright (c) 2013 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

RDEPENDS_${PN} += "\
    ltrace \
    "
